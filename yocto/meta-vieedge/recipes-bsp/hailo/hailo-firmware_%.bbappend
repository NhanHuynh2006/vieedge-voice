# meta-hailo declares LICENSE = "LICENSE" without a license text the SPDX task can find.
NO_GENERIC_LICENSE[LICENSE] = "LICENSE"
S = "${WORKDIR}"
